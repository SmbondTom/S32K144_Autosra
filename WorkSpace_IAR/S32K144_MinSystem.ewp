# IAR project S32K144_MinSystem.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ICCARM__; CPU_S32K144HFT0VLLT; DISABLE_MCAL_INTERMODULE_ASR_CHECK; _IAR_C_S32K14x_
  ICCARM.CCIncludePath2: ..\Source\Bsw\BswM; ..\Source\Bsw\Det; ..\Source\Bsw\EcuM; ..\Source\Bsw\Mcal_S32k; ..\Source\Bsw\Os; ..\Source\Bsw\VStdLib; ..\Source\Bsw\_Common; ..\Source\Mcal\Base_TS_T40D2M10I1R0\include; ..\Source\Mcal\Dio_TS_T40D2M10I1R0\include; ..\Source\Mcal\Mcu_TS_T40D2M10I1R0\include; ..\Source\Mcal\Port_TS_T40D2M10I1R0\include; ..\Source\StartupCode; ..\WorkSpace_Davinci\Appl\GenData; ..\WorkSpace_Davinci\Appl\GenData\Components; ..\WorkSpace_Davinci\Appl\GenData\include; ..\Include; ..\WorkSpace_Davinci\Appl\GenData\RteAnalyzer\Source; ..\WorkSpace_EBTresos\output\generated\include; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\BswM; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\Det; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\Dio; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\EcuM; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\Mcu; ..\WorkSpace_Davinci\Appl\GenData\ContractPhase\Port; ..\WorkSpace_Davinci\Appl\Source\Test_swc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: S32K144_MinSystem.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: G:\AutoProject144\S32k144_MinSystem\Link\S32K148Asr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ../Source/App
    ../Source/App/: main.c
  group ../Source/Bsw/BswM
    ../Source/Bsw/BswM/: BswM.c
  group ../Source/Bsw/Det
    ../Source/Bsw/Det/: Det.c
  group ../Source/Bsw/EcuM
    ../Source/Bsw/EcuM/: EcuM.c
  group ../Source/Bsw/Os
    ../Source/Bsw/Os/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Iar.c Os_Hal_Context_v7m.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group ../Source/Bsw/VStdLib
    ../Source/Bsw/VStdLib/: vstdlib.c
  group ../Source/Mcal/Dio_TS_T40D2M10I1R0/src
    ../Source/Mcal/Dio_TS_T40D2M10I1R0/src/: Dio.c Dio_Gpio.c
  group ../Source/Mcal/Mcu_TS_T40D2M10I1R0/src
    ../Source/Mcal/Mcu_TS_T40D2M10I1R0/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group ../Source/Mcal/Port_TS_T40D2M10I1R0/src
    ../Source/Mcal/Port_TS_T40D2M10I1R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group ../Source/StartupCode
    ../Source/StartupCode/: startup.c startup_S32K144.s system_S32K144.c
  group ../WorkSpace_Davinci/Appl/GenData
    ../WorkSpace_Davinci/Appl/GenData/: BswM_Lcfg.c BswM_PBcfg.c Det_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c Rte.c
  group ../WorkSpace_Davinci/Appl/GenData/src
    ../WorkSpace_Davinci/Appl/GenData/src/: Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group ../WorkSpace_Davinci/Appl/Source
    ../WorkSpace_Davinci/Appl/Source/: BswM_Callout_Stubs.c EcuM_Callout_Stubs.c Os_Callout_Stubs.c Test_swc.c
